# Repository gobabygocarswithjoysticks/gbg-pcb-2

File README.md:

# Moved to https://github.com/gobabygocarswithjoysticks/gbg-pcb

# GBG PCB

# A PCB for controlling the motors in a [go baby go car with joystick control](https://gobabygocarswithjoysticks.github.io/index/)

https://github.com/gobabygocarswithjoysticks/gbg-pcb

V2.1

This board replaces the control box of a car's original electronics or the separate ESCs and Arduino in the [usual joystick modification](https://gobabygocarswithjoysticks.github.io/index/). The board has screw terminals for connecting to the battery, motors, and the joystick. With this circuit board, a car can be converted to joystick control without any soldering.

Voltage input: 5 to 26 volts (6v, 12v, and 24v lead acid batteries, absolute maximum 4.6V-28V)

Controls two motors: one for each wheel so that the car can turn in place.

[New in version 2](https://gobabygocarswithjoysticks.github.io/gbg-pcb/instructions/instructions#new-in-v2-weelye-control-box-compatible): A V2 GBG-PCB can be configured with battery, motor, and signal plugs that match the plugs on the common weelye control boxes. This means some cars can be converted to joystick control without cutting any wires. V2 GBG-PCBs also run fron 6 to 24 volt batteries.

### For the previous versions of the GBG-PCB see https://github.com/gobabygocarswithjoysticks/gbg-pcb/tree/version_1 
Version 1 GBG-PCBs had a higher, 10 amp current capacity and a lower part count but requires 12 volts.

## Questions? Please email our support line at gbg-pcb@googlegroups.com

# Want one?
* Email pnwassistivetech@gmail.com or visit the [PNW Assistive Technology website](TODO/gbg-pcb). Thank you to PNWAT for supporting this project and being a supplier of these boards.
* Use this PCBWay link to order fully assembled boards: [PCBWay](https://www.pcbway.com/project/shareproject/GBG_PCB_Go_Baby_Go_Printed_Circuit_Board_V2_0_a8fd7fa3.html)
* Email gobabygocarswithjoysticks@gmail.com. I may have a small number of assembled V1 and V2 boards to sell or donate to you.
* Or please feel free to use these [files](/PCB_production) and get boards yourself. Instructions [here](https://gobabygocarswithjoysticks.github.io/gbg-pcb/instructions/how-to-make-boards)

# Software
## The website for uploading software to a GBG-PCB and adjusting settings is here: https://gobabygocarswithjoysticks.github.io/programmer/

# Instructions
## [general instructions for using this PCB](https://gobabygocarswithjoysticks.github.io/gbg-pcb/instructions/instructions)
### [instructions for assembling your own GBG-PCBs](https://gobabygocarswithjoysticks.github.io/gbg-pcb/instructions/how-to-make-boards)
## Index of Instructions for modifying specific models of cars using GBG-PCBs
* [Aosom Jeep - old model](https://gobabygocarswithjoysticks.github.io/gbg-pcb/instructions/car-specific/aosom-038-jeep/instructions) (car is out of production)
* [Zupapa Bumper Car](https://gobabygocarswithjoysticks.github.io/gbg-pcb/instructions/car-specific/zupapa-bumper-car/instructions) (instructions are complete through electronics but don't include a backrest or joystick holder)

# [schematic of PCB](/schematic.pdf)

# [PCB Production files](/PCB_production)

# [joystick to 4 wire cable connector PCB](https://github.com/gobabygocarswithjoysticks/gbg-pcb/tree/main/joystickpcb)
### This keeps you from needing to solder the joystick wires to a 4 wire cable.

# notes for people working on the KiCAD for this project
Use KiCAD 10.0

Run [this github action](https://github.com/gobabygocarswithjoysticks/gbg-pcb/actions/workflows/process-kicad.yml) when you push changes to any of the KiCAD files. The action updates the images of the CAD, the gerber files, the schematic, and other PCB production files. 

# photos

# images of CAD

# credits

## Prototype boards sponsored by PNW Assistive Technology

## This project was inspired by the [Go Baby Go project](https://health.oregonstate.edu/gobabygo) that modifies powerwheels cars for kids with disabilities

## Copyright: gobabygocarswithjoysticks and Joshua Phelps, MIT License

## KiCad design kicad/gbg-pcb.kicad_pcb

Parts:
3V1: green; LED_D3.0mm; Manufacturer_Part_Number BL-B2141K; digikey_part_number 2007-BL-B2141K-ND
B1, B2, B3, B4: ASJ-200-B-HT; ASJ200BHT; Manufacturer_Part_Number ASJ-200-B-HT; Mouser Part Number 737-ASJ-200-B-HT
C1, C2, C4, C6: 0.1uF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2X7R1H104K080AA; digikey_part_number 445-5666-1-ND
C3: 10uF; C_1210_3225Metric; Manufacturer_Part_Number MSASU32MSB5106KPNA01; digikey_part_number 587-MSASU32MSB5106KPNA01CT-ND
C5: 33uf; CAP_KK-8x8_KEM; Manufacturer_Part_Number A759KK336M1JAAE036; digikey_part_number 399-A759KK336M1JAAE036-ND
C7: 56pF; C_0603_1608Metric; Manufacturer_Part_Number CC0603JRNPO9BN560; digikey_part_number 311-1066-1-ND
C8: 47uF; C_1210_3225Metric; Manufacturer_Part_Number GRM32ER71A476KE15L; digikey_part_number 490-5312-1-ND
D1, D2: D_Schottky; D_SOD-123F; Manufacturer_Part_Number FS26; digikey_part_number 4786-FS26CT-ND
D3: 18V zener; D_SOD-123F; Manufacturer_Part_Number MMSZ5248B-E3-18; digikey_part_number MMSZ5248B-E3-18GICT-ND
D13: blue; LED_D5.0mm; Manufacturer_Part_Number BL-BBX1V4V-2-B02; digikey_part_number 2007-BL-BBX1V4V-2-B02-ND
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_ISO7380; Manufacturer_Part_Number DNP; digikey_part_number DNP
HSL1: Heatsink; heatsink 375424B00034G; Manufacturer_Part_Number 375424B00034G; digikey_part_number 375424B00034G-ND
HSR1: Heatsink; heatsink 375424B00034G; Manufacturer_Part_Number 375424B00034G; digikey_part_number 375424B00034G-ND
J1: 12 2.54mm pitch header pins; PinHeader_1x12_P2.54mm_Vertical; Manufacturer_Part_Number PH1-12-UA; digikey_part_number 2057-PH1-12-UA-ND
J2: Conn_01x04; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical; Manufacturer_Part_Number BM04B-SRSS-TB; digikey_part_number 455-BM04B-SRSS-TBCT-ND
J3: joystick; TC0403620000G; Manufacturer_Part_Number TC0403620000G; digikey_part_number TC0403620000G-ND
J4: speed knob; SAMESKY_TB0011-350-03GR; Manufacturer_Part_Number TB0011-350-03GR; digikey_part_number 2223-TB0011-350-03GR-ND
J5: TB005-762-02BE; CUI_TB005-762-02BE; Manufacturer_Part_Number TB005-762-02BE; digikey_part_number 102-6189-ND
J6: screw terminal; EBBA-02-C-SS-BU; Manufacturer_Part_Number EBBA-02-C-SS-BU; digikey_part_number 2057-EBBA-02-C-SS-BU-ND
J7, J8: 1017491; CONN_1017491; Manufacturer_Part_Number 1017491; digikey_part_number 277-17493-ND
J11: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical; Manufacturer_Part_Number PH1-10-UA; digikey_part_number 2057-PH1-10-UA-ND
J100, J101, J102, J103: 0197054001; Manufacturer_Part_Number 0197054001; digikey_part_number WM2982-ND; not fitted
J104: wellye style; CONN02_2159151002_MOL; Manufacturer_Part_Number 2159151002; digikey_part_number 23-2159151002-ND; not fitted
J105: wellye RX25 style; TE_1-1123723-2; Manufacturer_Part_Number 1-1123723-2; digikey_part_number A111830-ND; not fitted
L1: 12uH; IND_SRR6038-120Y; Manufacturer_Part_Number SRR6038-120Y; digikey_part_number SRR6038-120YCT-ND
NT1: NetTie_3; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm; Manufacturer_Part_Number DNP; digikey_part_number DNP
NT5, NT6, NT7, NT8: NetTie_2; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; Manufacturer_Part_Number DNP; digikey_part_number DNP
P1: rpi pico 1; RaspberryPi_Pico_Common_SMD; Manufacturer_Part_Number SC0915; digikey_part_number 2648-SC0915CT-ND
Q1, Q2: PSMN1R2-25YLDX; LFPAK56; Manufacturer_Part_Number PSMN1R2-25YLDX; digikey_part_number 1727-2496-1-ND
R1, R2: 220; R_0805_2012Metric; Manufacturer_Part_Number CRCW0805220RJNEA; digikey_part_number 541-220ACT-ND
R3, R15, R16: 3.3k; R_0805_2012Metric; Manufacturer_Part_Number CRCW08053K30FKEA; digikey_part_number 541-3.30KCCT-ND
R4, R9: 13.7k; R_0805_2012Metric; Manufacturer_Part_Number CRCW080513K7FKEA; digikey_part_number 541-13.7KCCT-ND
R5, R8, R13: 100k; R_0805_2012Metric; Manufacturer_Part_Number CRCW0805100KFKEA; digikey_part_number 541-100KCCT-ND
R6, R7, R14: 8.2k; R_0805_2012Metric; Manufacturer_Part_Number CRCW08058K20JNEA; digikey_part_number 541-8.2KACT-ND
R10: 220k; YC248-JR; Mfr PN YC248-JR-07220KL; digikey_part_number 13-YC248-JR-07220KLCT-ND
R11, R12: 604; R_0805_2012Metric; Manufacturer_Part_Number CRCW0805604RFKEA; digikey_part_number 541-604CCT-ND
SW1: screw terminal; EBBA-02-C-SS-BU; Manufacturer_Part_Number EBBA-02-C-SS-BU; digikey_part_number 2057-EBBA-02-C-SS-BU-ND
TP0: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm; Manufacturer_Part_Number DNP; digikey_part_number DNP
TP1, TP2: TestPoint; TestPoint_Pad_D2.0mm; Manufacturer_Part_Number DNP; digikey_part_number DNP
U1, U2: DRV8245HQPWPRQ1; HTSSOP28_PWP_TEX; Manufacturer_Part_Number DRV8245HQPWPRQ1; digikey_part_number 296-DRV8245HQPWPRQ1CT-ND
U3: TPS54202HDDCR; SOT95P280X110-6N tps54202HDDCR; Manufacturer_Part_Number TPS54202HDDCR; digikey_part_number 296-44396-1-ND
U4: TLA2024IRUGR; IC_TLA2024IRUGR; Mfr PN TLA2024IRUGR; digikey_part_number 296-51661-1-ND
U5: D78B05T, RBT05W24S05, pololu5593; D78B05T-1.0; not fitted

Connections:
5V: C7.1, C8.1, D1.2 (A), J1.1, L1.2, R8.1, U5.3 (OUT)
+3.3V: C4.1, J1.10, J2.2, J3.2, J4.3, NT1.3, P1.36 (3V3_OUT), R1.1, R15.1, R16.1, U4.8 (VDD)
+BATT: C1.1, C2.1, C3.1, C5.1, D2.1 (K), J1.12, J5.2, J6.2, J11.1, J102.1, J102.2, R3.1, R5.1, R13.1, U1.6 (VM), U1.7 (VM), U1.8 (VM), U1.21 (VM), U1.22 (VM), U1.23 (VM), U2.6 (VM), U2.7 (VM), U2.8 (VM), U2.21 (VM), U2.22 (VM), U2.23 (VM), U3.3 (VIN), U5.1 (IN)
/ML+: J7.1, J7.2, J101.1, J101.2, U1.9 (OUT1), U1.10 (OUT1), U1.11 (OUT1)
/ML-: J7.3, J7.4, J100.1, J100.2, U1.18 (OUT2), U1.19 (OUT2), U1.20 (OUT2)
/MR+: J8.3, J8.4, J104.2, J105.2, U2.18 (OUT2), U2.19 (OUT2), U2.20 (OUT2)
/MR-: J8.1, J8.2, J104.1, J105.1, U2.9 (OUT1), U2.10 (OUT1), U2.11 (OUT1)
GND: 3V1.1 (K), B1.1, B1.3, B2.1, B2.3, B3.1, B3.3, B4.1, B4.3, C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, D13.1 (K), J1.11, J2.1, J3.4, J4.1, J6.1, J11.5, NT1.1, P1.3 (GND), P1.8 (GND__1), P1.13 (GND__2), P1.18 (GND__3), P1.23 (GND__4), P1.28 (GND__5), P1.33 (AGND), P1.38 (GND__6), Q2.5 (D), R6.1, R7.1, R9.2, R10.2, R10.4, R10.6, R10.8, R11.1, R12.1, R14.2, U1.5 (DRVOFF), U1.12 (GND), U1.13 (GND), U1.14 (GND), U1.15 (GND), U1.16 (GND), U1.17 (GND), U1.28 (ITRIP), U1.EPAD, U2.5 (DRVOFF), U2.12 (GND), U2.13 (GND), U2.14 (GND), U2.15 (GND), U2.16 (GND), U2.17 (GND), U2.28 (ITRIP), U2.EPAD, U3.1 (GND), U4.3 (GND), U5.2 (GND); also elsewhere on the board
unnamed: 3V1.2 (A), R1.2
unnamed: D1.1 (K), P1.39 (VSYS)
unnamed: D2.2 (A), J11.3
unnamed: D3.2 (A), Q1.1 (S), Q1.2, Q1.3, Q2.1 (S), Q2.2, Q2.3, R4.1
unnamed: D3.1 (K), Q1.4 (G), R3.2, SW1.1 (A)
unnamed: D13.2 (A), R2.2
unnamed: J1.2, P1.16 (GP12)
unnamed: J1.3, P1.15 (GP11)
unnamed: J1.4, P1.14 (GP10)
unnamed: J1.5, P1.12 (GP9)
unnamed: J1.6, NT8.1, R10.10
unnamed: J1.7, NT7.1, R10.12
unnamed: J1.8, NT6.1, R10.14
unnamed: J1.9, NT5.1, R10.16
unnamed: J3.1, P1.31 (GP26)
unnamed: J3.3, P1.32 (GP27)
unnamed: J4.2, P1.34 (GP28)
unnamed: NT5.2, P1.7 (GP5), R10.1, R10.15
unnamed: NT6.2, P1.9 (GP6), R10.3, R10.13
unnamed: NT7.2, P1.10 (GP7), R10.5, R10.11
unnamed: NT8.2, P1.11 (GP8), R10.7, R10.9
unnamed: P1.17 (GP13), R2.1
unnamed: R7.2, U1.27 (MODE)
unnamed: R6.2, U2.27 (MODE)
unnamed: C6.2, U3.6 (BOOT)
unnamed: R5.2, U3.5 (EN)
unnamed: C7.2, R8.2, R9.1, U3.4 (FB)
unnamed: C6.1, L1.1, U3.2 (SW)
unnamed: NT1.2, U4.1 (ADDR)
unnamed: TP0.1 (1_1), U4.4 (AIN0)
unnamed: R13.2, R14.1, U4.6 (AIN2)
bat-: J5.1, J11.4, J103.1, J103.2, Q1.5 (D)
bt1: B1.2, P1.2 (GP1)
bt2: B2.2, P1.4 (GP2)
bt3: B3.2, P1.5 (GP3)
bt4: B4.2, P1.6 (GP4)
left_1: P1.29 (GP22), U1.4 (EN/IN1)
left_2: P1.26 (GP20), U1.3 (PH/IN2)
left_en: P1.27 (GP21), U1.24 (NSLEEP)
left_ipropi: R11.2, TP1.1 (1_1), U1.25 (IPROPI), U4.7 (AIN3)
right_1: P1.22 (GP17), U2.3 (PH/IN2)
right_2: P1.21 (GP16), U2.4 (EN/IN1)
right_en: P1.24 (GP18), U2.24 (NSLEEP)
right_ipropi: R12.2, TP2.1 (1_1), U2.25 (IPROPI), U4.5 (AIN1)
scl: J2.4, P1.20 (GP15), R16.2, U4.10 (SCL)
sda: J2.3, P1.19 (GP14), R15.2, U4.9 (SDA)
switch: J11.2, Q2.4 (G), R4.2, SW1.2 (B)

Notes on the sheet:
reverse polarity protection
8.2k +-10% LVL2 INDEPENDENT
LVL6, in independent mode that means faults are retried
optionally replace J8 to make the PCB weelye compatible
optionally replace J7 to be weelye compatible
NMOS
on/off switch
pullup resistors
optionally replace J5 to be weelye compatible
3mm diameter bolt holes 3.35in x 2.2in 85.09mm x 55.88mm
ADC (for measuring battery voltage and motor current)
weelye compatible header
battery power circuit
3.5mm audio jacks for if you want to connect buttons as an alternative to the joystick
alternative voltage regulator Instead of the voltage regulator circuit, you could get a single THT module that outputs 5V. Make sure the pinout matches. Make sure the min and max input voltage are compatible with your battery.
voltage regulator circuit https://webench.ti.com/appinfo/webench/scripts/SDP.cgi?ID=F7F7D983B50C08E2
qwiic I2C plug
left motor
Raspberry Pi Pico

Board: 2 copper layers, 91.4 x 62.2 mm, 76 parts (9 on the bottom side), 55 nets.

Other parts of the board:
FID1: 1; Fiducial_1mm_Mask3mm
FID2: 2; Fiducial_1mm_Mask3mm
FID3: 3; Fiducial_1mm_Mask3mm
JGND2: Conn_01x02; TestPoint_Bridge_Pitch3.81mm_Drill1.3mm

Their connections:
GND: JGND2.1 (Pin_1_1); also elsewhere on the board

File PCB_production/BOM-with-DNP.csv:

"Reference","Value","Footprint","Manufacturer_Name","Manufacturer_Part_Number","digikey_part_number","mount_type","QUANTITY"
"3V1","green","LED_THT:LED_D3.0mm","American Bright Optoelectronics Corporation","BL-B2141K","2007-BL-B2141K-ND","tht","1"
"B1-B4","ASJ-200-B-HT","kicad libraries:ASJ200BHT","Adam Tech","ASJ-200-B-HT","2057-ASJ-200-B-HT-ND","tht","4"
"C1,C2,C4,C6","0.1uF","Capacitor_SMD:C_0603_1608Metric","TDK Corporation","CGA3E2X7R1H104K080AA","445-5666-1-ND","smd","4"
"C3","10uF","Capacitor_SMD:C_1210_3225Metric","Taiyo Yuden","MSASU32MSB5106KPNA01","587-MSASU32MSB5106KPNA01CT-ND","smd","1"
"C5","33uf","kicad libraries:CAP_KK-8x8_KEM","KEMET","A759KK336M1JAAE036","399-A759KK336M1JAAE036-ND","tht","1"
"C7","56pF","Capacitor_SMD:C_0603_1608Metric","Yageo","CC0603JRNPO9BN560 ","311-1066-1-ND","smd","1"
"C8","47uF","Capacitor_SMD:C_1210_3225Metric","MuRata","GRM32ER71A476KE15L","490-5312-1-ND","smd","1"
"D1,D2","D_Schottky","Diode_SMD:D_SOD-123F","Good-Ark Semiconductor","FS26","4786-FS26CT-ND","smd","2"
"D3","18V zener","Diode_SMD:D_SOD-123F","Vishay General Semiconductor - Diodes Division","MMSZ5248B-E3-18","MMSZ5248B-E3-18GICT-ND","smd","1"
"D13","blue","LED_THT:LED_D5.0mm","American Bright Optoelectronics Corporation","BL-BBX1V4V-2-B02","2007-BL-BBX1V4V-2-B02-ND","tht","1"
"HSL1,HSR1","Heatsink","kicad libraries:heatsink 375424B00034G","Boyd Laconia, LLC","375424B00034G","375424B00034G-ND","tht","2"
"J1","12  2.54mm pitch header pins","Connector_PinHeader_2.54mm:PinHeader_1x12_P2.54mm_Vertical","Any Manufacturer","PH1-12-UA","2057-PH1-12-UA-ND","tht","1"
"J2","Conn_01x04","Connector_JST:JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical","JST Sales America Inc.","BM04B-SRSS-TB","455-BM04B-SRSS-TBCT-ND","smd","1"
"J3","joystick","kicad libraries:TC0403620000G","Amphenol Anytek","TC0403620000G","TC0403620000G-ND","tht","1"
"J4","speed knob","kicad libraries:SAMESKY_TB0011-350-03GR","Same Sky (Formerly CUI Devices)","TB0011-350-03GR","2223-TB0011-350-03GR-ND","tht","1"
"J5","TB005-762-02BE","kicad libraries:CUI_TB005-762-02BE","Same Sky (Formerly CUI Devices)","TB005-762-02BE","102-6189-ND","tht","1"
"J6,SW1","screw terminal","kicad libraries:EBBA-02-C-SS-BU","Adam Tech","EBBA-02-C-SS-BU","2057-EBBA-02-C-SS-BU-ND","tht","2"
"J7,J8","1017491","kicad libraries:CONN_1017491","Phoenix Contact","1017491","277-17493-ND","tht","2"
"J11","Conn_01x10_Pin","Connector_PinHeader_2.54mm:PinHeader_1x10_P2.54mm_Vertical","Any Manufacturer","PH1-10-UA","2057-PH1-10-UA-ND","tht","1"
"J100-J103","0197054001","kicad libraries:0197054001","Molex","0197054001","WM2982-ND","tht","4"
"J104","wellye style","kicad libraries:CONN02_2159151002_MOL","Molex","2159151002","23-2159151002-ND","tht","1"
"J105","wellye RX25 style","kicad libraries:TE_1-1123723-2","TE Connectivity AMP Connectors","1-1123723-2","A111830-ND","tht","1"
"L1","12uH","kicad libraries:IND_SRR6038-120Y","Bourns","SRR6038-120Y","SRR6038-120YCT-ND","smd","1"
"P1","rpi pico 1","Module:RaspberryPi_Pico_Common_SMD","Raspberry Pi","SC0915","2648-SC0915CT-ND","tht","1"
"Q1,Q2","PSMN1R2-25YLDX","Package_TO_SOT_SMD:LFPAK56","Nexperia USA Inc.","PSMN1R2-25YLDX","1727-2496-1-ND","smd","2"
"R1,R2","220","Resistor_SMD:R_0805_2012Metric","Vishay Dale","CRCW0805220RJNEA","541-220ACT-ND","smd","2"
"R3,R6,R7","8.2k","Resistor_SMD:R_0805_2012Metric","Vishay Dale","CRCW08058K20JNEA","541-8.2KACT-ND","smd","3"
"R4,R5,R8,R13","100k","Resistor_SMD:R_0805_2012Metric","Vishay Dale","CRCW0805100KFKEA","541-100KCCT-ND","smd","4"
"R9,R14","13.7k","Resistor_SMD:R_0805_2012Metric","Vishay Dale","CRCW080513K7FKEA","541-13.7KCCT-ND","smd","2"
"R10","220k","kicad libraries:YC248-JR","YAGEO","YC248-JR-07220KL","13-YC248-JR-07220KLCT-ND","smd","1"
"R11,R12","604","Resistor_SMD:R_0805_2012Metric","Vishay Dale","CRCW0805604RFKEA","541-604CCT-ND","smd","2"
"R20","EXB34V182JV","kicad libraries:C_ARRAY_EXB34V_PAN","Panasonic Industry","EXB-34V182JV","Y8182CT-ND","smd","1"
"U1,U2","DRV8245HQPWPRQ1","kicad libraries:HTSSOP28_PWP_TEX","Texas Instruments","DRV8245HQPWPRQ1","296-DRV8245HQPWPRQ1CT-ND","smd","2"
"U3","TPS54202HDDCR","kicad libraries:SOT95P280X110-6N tps54202HDDCR","Texas Instruments","TPS54202HDDCR","296-44396-1-ND","smd","1"
"U4","TLA2024IRUGR","kicad libraries:IC_TLA2024IRUGR","Texas Instruments","TLA2024IRUGR","296-51661-1-ND","smd","1"

## Commit log (part)

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2025-03-23 BOT render images
2025-03-23 BOT process kicad
2025-03-24 change and label capacitors
2025-03-24 round corners
2025-03-25 joystickpcb
2025-03-26 export solder paste stencil DXF
2025-03-27 update values for bom
2025-04-04 fix mosfet circuit
2025-04-05 v1.1
2025-04-05 adjust labels
2025-04-06 adjust layout and heatsink
2025-04-06 adjust layout
2025-04-10 Update and rename GBG-PCB.md to index
2025-04-10 Rename index to index.md
2025-04-10 edit readme
2025-04-10 Create photos
2025-04-10 add photo
2025-04-13 add circuit diagram
2025-04-16 add pictures of v1.1
2025-04-16 update readme and instructions
2025-04-17 update documentation
2025-04-23 v1.2 (update BOM and adjust silkscreen)
2025-04-25 different heatsinks
2025-04-26 adjust heatsink
2025-04-28 readme
2025-05-01 update docs for how to get boards
2025-05-01 fix text content include
2025-05-01 add links
2025-05-01 edit instructions.md
2025-06-02 change pcb to use 26mm thermal tape and start instructions
2025-06-04 add 3d models to library
2025-06-04 update model for header pins
2025-06-06 add photos
2025-06-07 work on instructions
2025-06-15 update ir image
2025-06-18 Rename secure_pcb.JPG to secure_pcb.jpg
2025-06-18 update instructions
2025-06-18 fix link markdown
2025-06-18 update how to get boards
2025-07-22 add link to user guide
2025-08-23 start of bumper car instructions
2025-08-25 update images of gbg-pcb
2025-08-27 add some images
2025-09-03 add instructions and pictures
2025-09-03 add missing line break
2025-09-03 move image
2025-09-03 edit instructions
2025-09-12 update docs
2025-09-15 edit general instructions
2025-09-16 update readme for pcb production
2025-09-20 add harness steps
2025-09-20 edit harness steps
2025-09-20 edit instructions for jeep
2025-09-20 add harness photo
2025-09-21 update jeep photo
2025-09-21 update photo
2025-09-21 spelling
2025-12-22 starting pcb layout
2025-12-22 some layout
2025-12-22 update script
2025-12-22 working on layout
2025-12-23 arrange
2025-12-23 work on layout
2025-12-23 draw traces
2025-12-23 layout
2025-12-28 Add no-background-color option to PDF export
2026-04-16 fix script
2026-04-16 add debugging to script
2026-04-18 fix parts for voltage regulator and add weelye tabs
2026-04-18 adjust script
2026-04-19 add sponsor logo and work on readme
2026-04-19 add new email
2026-04-19 arrange schematic
2026-04-20 reviewed
2026-04-26 add notes on what parts can be omitted to reduce cost
2026-04-28 BOT Update interactive BOM
2026-04-28 mark placed
2026-05-02 v2.1
2026-05-02 adjust silkscreen and minor layout changes
2026-05-03 adjust traces
2026-05-03 arrange silkscreen and traces
2026-05-03 add images
2026-05-05 add vias
2026-05-05 work on right motor connection
2026-05-07 updates from assembling V2.1, and silkscreen
2026-05-11 change resistors
2026-05-12 adjust layout and heatsink pads
2026-05-21 change weelye plug pinout after testing
